# IAR project i2c.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; 
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: i2c.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: driver_funcs.c driver_funcs.h i2c_acc.c i2c_acc.h lsm6ds3.h main.c
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_i2c.c stm8s_tim4.c stm8s_uart2.c
