<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\fuel_level\fuel_level.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2c.ewp</path>
  </project>
  <batchBuild/>
</workspace>


