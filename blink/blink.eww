<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8_blink.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\uart2\uart2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


